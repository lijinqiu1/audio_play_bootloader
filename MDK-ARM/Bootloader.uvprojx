# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Bootloader
  AfterMake: F:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./Bootloader/Update.bin ./Bootloader/Bootloader.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c misc: --C99
  c include: ../Inc;F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Inc;F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Middlewares/Third_Party/FatFs/src;F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Drivers/CMSIS/Include;..\IAP;..\BOOTLOADER;..\STMFLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_gpio.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    F:/STM32Cube/STM32Cube_FW_F4_V1.18.0/Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/User
    ../Src/: gpio.c bsp_driver_sd.c sdio.c stm32f4xx_it.c sd_diskio.c spi.c stm32f4xx_hal_msp.c usart.c main.c dma.c fatfs.c oled.c oledfont.c
    ../BOOTLOADER/: Bootloader.c
    ../IAP/: iap.c
    ../STMFLASH/: stmflash.c
software components: CMSIS:CORE 4.1.0
